# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c delay.h lcd1602.c lcd1602.h Switch0000.c switch0000.h Timer0.c Timer0.h Servo.c Servo.h RedWAI.c RedWAI.h
